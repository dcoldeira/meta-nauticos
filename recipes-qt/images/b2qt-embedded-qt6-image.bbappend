SUMMARY = "NauticOS An small OS for marine navegation softwares targeting small single-board computers (SBCs) and the alike architectures."
IMAGE_INSTALL_prepend := "desktop" 
